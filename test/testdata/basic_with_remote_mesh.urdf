Commit message: Intermediate fix for loading meshes.

File: test/testdata/basic_with_remote_mesh.urdf (robot description, URDF)
Before this commit: robot myfirst, 1 links, 0 joints
Links:
- link base_link: geometry visual mesh filename=https://upload.wikimedia.org/wikipedia/commons/3/36/3D_mode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
